# Keil uVision project TB4000_PanelV02.uvproj, settings and files
target TB4000_PanelV02 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: TB4000_PanelV02 +hex
  AfterMake: fromelf --bin ".\Output_PanelV02\TB4000_PanelV02.axf" --output ".\Output_PanelV02\firmware_TB4000_PanelV02.bin"
  c flags: Optim=1
  c define: _PANEL_VERSION = _RX_V02,_SAMPLE_FREQ = 500
  c include: .\SourceCode;.\Core\GLCD;.\Core\SysTick;.\Core\RTC;.\GUI\Config;.\GUI\Core;.\Core\common\inc;.\Core\ADC;.\Core\DAC;.\Core\SD;.\Core\SPI;.\Core\Serial;.\Core\USB;.\Core\HID;.\Core\FLASH;.\Core\I2C;.\Core\TIMER;.\Core\PWM;.\UI_V01;.\menu
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./Core/common/src/: startup_LPC17xx.s
  group System Code
    ./Core/common/src/: system_LPC17xx.c
  group Core Code
    ./Core/common/src/: core_cm3.c
    ./Core/FLASH/: spi_flash.c
    ./Core/GLCD/: RX_LCD_V02.c
    ./Core/SysTick/: systick.c
    ./Core/TIMER/: timer.c
    ./Core/Serial/: uart.c
    ./Core/SPI/: SPI.c
    ./Core/RTC/: rtc.c
  group Source Code
    ./SourceCode/: main.c eeprom_flash.c struct.c touchpad.c compress.c pump.c system.c
  group Menu
    ./menu/: menufunc.c menutbl.c menu.c
